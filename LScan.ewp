# IAR project LScan.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DLIB_ADD_C99_SYMBOLS; USE_STDPERIPH_DRIVER; STM32F4XX; ARM_MATH_CM4; LSCAN_TYPES
  ICCARM.CCIncludePath2: ; MM; OS; Libraries\FatFS_Library; Libraries\FatFS_Library\ff; Libraries\FatFS_Library\low_level; Libraries\FatFS_Library\ff\option; Libraries\CMSIS\include; Libraries\CMSIS\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver; Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\CMSIS\DSP_Lib\Examples\Common\Include; Utilities\STM32F4-Discovery; Libraries\Audio; Libraries\Audio\helix; Libraries\Audio\helix\pub; Libraries\Audio\helix\real; spi_wlan
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LScan.bin
  ILINK.IlinkOutputFile: LScan.out
  ILINK.IlinkIcfFile: LScan_CCM_RAM_STACK.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Audio
    Libraries/Audio/: Audio.c Audio.h utils.c
  group Audio/Helix
    Libraries/Audio/helix/: mp3dec.c mp3tabs.c platform.h
  group Audio/Helix/pub
    Libraries/Audio/helix/pub/: mp3common.h mp3dec.h mpadecobjfixpt.h statname.h
  group Audio/Helix/real
    Libraries/Audio/helix/real/: assembly.h bitstream.c buffers.c coder.h dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs_fixpt.c
  group CMSIS
    $EW_DIR$/arm/inc/c/: cmsis_iar.h
    Libraries/CMSIS/Include/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group EWARM
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group FatFS/ff
    Libraries/FatFS_Library/ff/: diskio.c diskio.h ff.c ff.h ffconf.h fs_sync.c integer.h
    Libraries/FatFS_Library/ff/option/: unicode.c
  group FatFS/low_level
    Libraries/FatFS_Library/low_level/: sdcard.c sdcard.h spi_card.c spi_card.h
  group LScan_ILDA/FONT_VECTOR
    ./: font_def.h font_func.c font_func.h FontMicrosoftSansSerif_14_1.h
  group LScan_ILDA/ILDA_player
    ./: files_control.c files_control.h ILDA_player.c ILDA_player.h Pangolin8bitPalette.h
  group MM
    MM/: CCM_MM_RAM.c CCM_MM_RAM.h MPU.c MPU.h
  group OS
    OS/: core.c core_a.s core_SystemTimer.c deff_tasks.c pendsv.s sync.c tsvc.s
    ./: LScan_CCM_RAM_STACK.icf
  group OS/headers
    OS/: atomic.h core.h core_def.h core_types.h
  group spi_wlan
    spi_wlan/: spi_wlan.c spi_wlan.h
  group STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ./: Hardware.c LScan.c main.c stm32f4xx_it.c system_stm32f4xx.c User_Interface.c
  group User/headers
    ./: Hardware.h LScan.h LScan_types.h notes.h
